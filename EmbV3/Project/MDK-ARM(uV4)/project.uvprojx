# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F429ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,STM32F429_439xx
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp\inc;..\..\User\app;..\..\User\bsp;..\..\LWIP;..\..\LWIP\arch;..\..\MALLOC;..\..\LWIP\lwip_app\lwip_comm;..\..\LWIP\lwip_app;..\..\LWIP\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\src\include\ipv4;..\..\LWIP\lwip-1.4.1\src\include\lwip;..\..\LWIP\lwip-1.4.1\src\include\netif;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Libraries\CMSIS\DSP_Lib\Source\FastMathFunctions;..\..\FreeRTOSv8.1.2\Source\portable\RVDS\ARM_CM4F;..\..\FreeRTOSv8.1.2\Source\include;..\..\FreeRTOSv8.1.2\Source\CMSIS_RTOS;..\..\User\app\System;..\..\User\bsp\Sys;..\..\User\app\Module\Led;..\..\Libraries\FatFS;..\..\User\app\System\FileSys;..\..\User\app\CommProtocol\Emb_PC;..\..\User\app\CommProtocol\Emb_MyServo;..\..\User\app\CommProtocol\Emb_Gripper;..\..\User\app\System\tasks;..\..\User\app\Module\PSM;..\..\User\app\Module\BatteryCharger;..\..\User\app\CommProtocol\Emb_PSM;..\..\User\bsp\Userlib;..\..\User\bsp\Sys;..\..\User\app\CommProtocol\Emb_BatteryCharger;..\..\User\app\Module\Arms;..\..\User\app\Module\Grippers;..\..\User\app\Module\Head;..\..\User\app\Module\IMU;..\..\User\app\Module\Wheel;..\..\User\app\Module\Shoulder;..\..\User\app\Module\Radar;..\..\User\app\Module\Wheel;..\..\User\app\CommProtocol\Emb_Gripper;..\..\User\app\CommProtocol\Emb_Mic;..\..\User\app\Module\MIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group User
    ../../User/app/System/: main.c
  group APP_Module
    ../../User/app/Module/Arms/: Arms.c Arms_Cmd.c Arms_Status.c
    ../../User/app/Module/Shoulder/: Shoulder.c Shoulder_Cmd.c Shoulder_Status.c
    ../../User/app/Module/Head/: Head.c Head_Cmd.c Head_Status.c
    ../../User/app/Module/Grippers/: Grippers.c Grippers_Cmd.c Grippers_Status.c
    ../../User/app/Module/Wheel/: Wheel.c Wheel_Cmd.c Wheel_Status.c
    ../../User/app/Module/Led/: Led.c
    ../../User/app/Module/IMU/: IMU.c IMU_Status.c
    ../../User/app/Module/MIC/: Mic.c
    ../../User/app/Module/Radar/: Radar.c Radar_Status.c
    ../../User/app/Module/PSM/: PSM.c PSM_Cmd.c PSM_Status.c
    ../../User/app/Module/BatteryCharger/: BatteryCharger.c BatteryCharger_Cmd.c BatteryCharger_Status.c
    ../../User/app/System/tasks/: EmbSysProc.c
    ../../User/bsp/Sys/: sys_utils.c
  group APP_CommProtocol
    ../../User/app/CommProtocol/Emb_PC/: Emb_PC.c
    ../../User/app/CommProtocol/Emb_MyServo/: Emb_MyServo.c
    ../../User/app/CommProtocol/Emb_Gripper/: Emb_Gripper.c
    ../../User/app/CommProtocol/Emb_PSM/: Emb_PSM.c
    ../../User/app/CommProtocol/Emb_BatteryCharger/: Emb_BatteryCharger.c
    ../../User/app/CommProtocol/Emb_Mic/: Emb_Mic.c
  group APP_FS
    ../../User/app/System/FileSys/: filesys.c
  group BSP
    ../../User/bsp/: bsp.c stm32f4xx_assert.c stm32f4xx_it.c
    ../../User/bsp/ETHERNET/: stm32f4x7_eth.c
    ../../User/bsp/Timer/: bsp_timer.c
    ../../User/bsp/Gpio/: bsp_gpio.c
    ../../User/bsp/Ethernet/: bsp_eth.c
    ../../User/bsp/Dma/: bsp_uart_dma.c
    ../../User/bsp/Uart/: bsp_uarts.c
    ../../User/bsp/I2c/: bsp_i2c.c
    ../../User/bsp/Adc/: bsp_adc.c
    ../../User/bsp/Tim/: bsp_tim.c
    ../../User/bsp/Spi/: bsp_spi.c
    ../../User/bsp/Userlib/: bsp_userlib.c
  group FS
    ../../Libraries/FatFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group FreeRTOS
    ../../FreeRTOSv8.1.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../FreeRTOSv8.1.2/Source/CMSIS_RTOS/: cmsis_os.c
    ../../FreeRTOSv8.1.2/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOSv8.1.2/Source/portable/MemMang/: heap_4.c
  group MALLOC
    ../../MALLOC/: malloc.c
  group LWIP_APP
    ../../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../../LWIP/lwip_app/: tcp_server.c
  group LWIP_NETIF
    ../../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c udp.c tcp_timers.c
  group LWIP_ARCH
    ../../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Include/: arm_math.h arm_common_tables.h core_cm4.h
    ../../Libraries/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../../Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_dbgmcu.c stm32f4xx_iwdg.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
